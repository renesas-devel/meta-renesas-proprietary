include core-image-weston-proprietary.inc
