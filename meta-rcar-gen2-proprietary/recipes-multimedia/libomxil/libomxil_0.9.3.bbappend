do_populate_sysroot () {
	rm -r ${D}/usr/include/*.h
}
