include core-image-x11-proprietary.inc